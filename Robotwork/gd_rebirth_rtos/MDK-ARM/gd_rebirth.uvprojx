# Keil uVision project gd_rebirth.uvprojx, settings and files
target gd_rebirth (6220000::V6.22::ARMCLANG)
  device: STM32G473VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: gd_rebirth +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G473xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../mcu_bsp/fdcan;../mcu_bsp/Motor;../Device;../Task;../mcu_bsp/system_controller;../mcu_bsp/Encoder;../mcu_bsp/IMU;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../state_controller;..\mcu_bsp\uart
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Core/Src/: mainwork.c main.c gpio.c app_freertos.c fdcan.c i2c.c usart.c spi.c tim.c usb.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../mcu_bsp/fdcan/: bsp_fdcan.c
    ../mcu_bsp/Motor/: dc_motor.c
    ../mcu_bsp/system_controller/: pid.c
    ../mcu_bsp/Encoder/: encoder.c
    ../mcu_bsp/uart/: bsp_usart.c
  group Device
    ../Device/: tcs230.c gray.c
    ../mcu_bsp/IMU/: icm_42688.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group state_controller
    ../state_controller/: state_machine.c
software components: CMSIS:CORE 6.1.0
