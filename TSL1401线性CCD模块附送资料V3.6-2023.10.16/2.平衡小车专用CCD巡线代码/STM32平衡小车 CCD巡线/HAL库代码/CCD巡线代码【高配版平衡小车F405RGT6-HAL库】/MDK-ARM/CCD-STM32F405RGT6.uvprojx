# Keil uVision project CCD-STM32F405RGT6.uvprojx, settings and files
target CCD-STM32F405RGT6 (6220000::V6.22::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CCD-STM32F405RGT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\SYSTEM\sys;..\SYSTEM\delay;..\MiniBalance\CONTROL;..\MiniBalance\DataScope_DP;..\MiniBalance\DMP;..\MiniBalance\filter;..\MiniBalance\MPU6050;..\MiniBalance\show;..\MiniBalance_HARDWARE\ADC;..\MiniBalance_HARDWARE\ENCODER;..\MiniBalance_HARDWARE\IIC;..\MiniBalance_HARDWARE\OLED;..\MiniBalance_HARDWARE\USARTX;..\MiniBalance_HARDWARE\LED;..\MiniBalance_HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hareware
    ../MiniBalance_HARDWARE/ENCODER/: encoder.c
    ../MiniBalance_HARDWARE/IIC/: IOI2C.c
    ../MiniBalance_HARDWARE/KEY/: key.c
    ../MiniBalance_HARDWARE/LED/: LED.C
    ../MiniBalance_HARDWARE/OLED/: oled.c
    ../MiniBalance_HARDWARE/USARTX/: usartx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group MiniBlance
    ../MiniBalance/CONTROL/: control.c
    ../MiniBalance/DataScope_DP/: DataScope_DP.C
    ../MiniBalance/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MiniBalance/filter/: filter.c
    ../MiniBalance/MPU6050/: MPU6050.c
    ../MiniBalance/show/: show.c
software components: CMSIS:CORE 6.1.0
